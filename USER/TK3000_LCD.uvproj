# Keil uVision project TK3000_LCD.uvproj, settings and files
target TK3000_LCD (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: TK3000_LCD +hex
  AfterMake: fromelf.exe --bin -o ../OUTPUT/TK3000_LCD.bin  ../OUTPUT/TK3000_LCD.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F4XX,USE_USB_OTG_FS, USE_EMBEDDED_PHY, USE_STDPERIPH_DRIVER, __FPU_PRESENT = 1,__FPU_USED = 1,ARM_MATH_CM4, __CC_ARM
  c misc: --c99 --locale=english --diag_suppress=870
  c include: ..\STM32F40x_FWLib\inc;..\STM32F40x_FWLib\src;..\USER;..\CORE;.\Public;.\UI;.\BSP;.\COM;.\emWin\Include;.\emWin\Config;.\emWin\GUI_X;.\emWin\Driver;.\emWin\Fonts;.\DAL;.\USBH_APP;..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\Libraries\STM32_USB_HOST_Library\Core\inc;..\Libraries\STM32_USB_OTG_Driver\inc;..\Libraries\STM32_USB_Device_Library\Class\msc\inc;..\Libraries\STM32_USB_Device_Library\Core\inc;.\USBD_APP;.\emWin\FontLib;.\FATFS\src;.\emWin\PNG;.\emWin\UI_Public
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c readme.txt
  group BSP
    ./BSP/: stm32f4xx_it.c SysTick_Timer.c bsp_fsmc_sram.c MemoryAlloc.h bsp_nand_flash.c RTC_F4xx.c
  group COM
    ./COM/: COM.c Protocol.c CMD.c
  group Public
    ./Public/: PublicFunction.c Delay.c DateTime.c Encrypt_XYQ.c Handlers.h
  group DAL
    ./DAL/: Parameter.c FileOperate.c SysParameter.c
  group UI
    ./UI/: MainTask.c WorkForm.c USBFunc_Ctr.c Register.c MotorControl.c WelcomForm.c
  group UI_Public
    ./emWin/UI_Public/: pymb.c SoftKeyboard.c NumKeyForm.c PicDisplay.c MessageBox.c MessageBox_NoBtn.c XBFFont.c UIPublic.c FullKeyForm.c
  group Fonts
    ./emWin/Fonts/: asc12.c asc16.c hz16.c hz24.c hz32.c ra8875_asc_width.c hz12.c
  group LCD_Driver
    ./emWin/Driver/: GUIDRV_Template.c bsp_ra8875_port.c bsp_tft_lcd.c bsp_touch.c LCD_RA8875.c LCDPara.c
  group GUI_X
    ./emWin/GUI_X/: GUI_X.c
  group GUI_Config
    ./emWin/Config/: GUIConf.c LCDConf.c
  group GUILib
    ./emWin/GUILib/: STemWin528_CM4_Keil_ot.lib
  group GUI_PNG
    ./emWin/PNG/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c gzio.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
  group FATFS
    ./FATFS/src/: diskio.c ff.c
    ./FATFS/src/option/: cc936.c
  group USB_Host_Driver
    ../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USBH_APP
    ./USBH_APP/: usb_bsp.c usbh_usr.c
  group USBD_APP
    ./USBD_APP/: usb_it.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group USBD_Lib
    ../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_OTG
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_dcd.c usb_dcd_int.c
  group FWLIB
    ../STM32F40x_FWLib/src/: stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c misc.c stm32f4xx_sdio.c
    ../STM32F40x_FWLib/: startup_stm32f40_41xxx.s system_stm32f4xx.c
